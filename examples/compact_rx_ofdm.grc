<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>mods[modulation]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>(float(occupied_carriers) / float(fft_len)) / 2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ks0</value></param>
<param><key>value</key><value>gp.gen_preamble_data(fft_len , occupied_carriers)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_fft_shift</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mods</value></param>
<param><key>value</key><value>{"bpsk": 2, "qpsk": 4, "8psk": 8, "qam8": 8, "qam16": 16, "qam64": 64, "qam256": 256}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulation</value></param>
<param><key>value</key><value>'bpsk'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phgain</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rcvd_pktq</value></param>
<param><key>value</key><value>gr.msg_queue()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rotated_const</value></param>
<param><key>value</key><value>gp.gen_framer_info(modulation)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10000000/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tb</value></param>
<param><key>value</key><value>bw*0.08</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>view</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>watcher</value></param>
<param><key>value</key><value>pp._queue_watcher_thread(rcvd_pktq,view)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>win</value></param>
<param><key>value</key><value>[1 for i in range(fft_len )]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zeros_on_left</value></param>
<param><key>value</key><value>int(math.ceil((fft_len - occupied_carriers)/2.0))</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/data.txt</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>occupied_carriers</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>occupied_carriers</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>occupied_carriers</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>occupied_carriers</value></param>
</block>
<block>
<key>equalize_chains</key>
<param><key>id</key><value>equalize_chains_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>nports</key><value>4</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>filter.firdes.low_pass (1.0, 1.0, bw+tb, tb, filter.firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>filter.firdes.low_pass (1.0, 1.0, bw+tb, tb, filter.firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>filter.firdes.low_pass (1.0, 1.0, bw+tb, tb, filter.firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>filter.firdes.low_pass (1.0, 1.0, bw+tb, tb, filter.firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import ofdm.gen_preamble as gp</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>from gnuradio import gr</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_1</value></param>
<param><key>import</key><value>import ofdm.packet_process as pp</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_1_0</value></param>
<param><key>import</key><value>import ofdm</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_2</value></param>
<param><key>import</key><value>import ofdm.gen_preamble as gp</value></param>
</block>
<block>
<key>ofdm_eadf_doa</key>
<param><key>id</key><value>ofdm_eadf_doa_0</value></param>
<param><key>fft_res</key><value>256</value></param>
<param><key>matfile</key><value>/home/travis/Dropbox/PHD/WiFiUS/doa/gnuradio/gr-ofdm/matlab_code/data.mat</value></param>
<param><key>num_ants</key><value>4</value></param>
</block>
<block>
<key>ofdm_m_channel_sync</key>
<param><key>id</key><value>ofdm_m_channel_sync_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>max_fft_shift</key><value>max_fft_shift</value></param>
</block>
<block>
<key>ofdm_ofdm_mrx_frame_sink</key>
<param><key>id</key><value>ofdm_ofdm_mrx_frame_sink_0</value></param>
<param><key>frq_gain</key><value>phgain*phgain /4.0</value></param>
<param><key>queue</key><value>rcvd_pktq</value></param>
<param><key>occ_tones</key><value>occupied_carriers</value></param>
<param><key>ph_gain</key><value>phgain</value></param>
<param><key>inputs</key><value>4</value></param>
<param><key>syms</key><value>rotated_const</value></param>
<param><key>vals</key><value>range(arity)</value></param>
</block>
<block>
<key>ofdm_packet_sync</key>
<param><key>id</key><value>ofdm_packet_sync_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
</block>
<block>
<key>phase_correct_hier</key>
<param><key>id</key><value>phase_correct_hier_1</value></param>
<param><key>config_filename</key><value>/tmp/measure_X310_TwinRX_phase_offsets_245.cfg</value></param>
<param><key>num_ports</key><value>4</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>marker2</key><value>1</value></param>
<param><key>color3</key><value>"red"</value></param>
<param><key>marker3</key><value>2</value></param>
<param><key>color4</key><value>"red"</value></param>
<param><key>marker4</key><value>3</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>20</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>twinrx_usrp_source</key>
<param><key>id</key><value>twinrx_usrp_source_0</value></param>
<param><key>center_freq</key><value>2.45e9</value></param>
<param><key>addresses</key><value>"addr=192.168.50.2"</value></param>
<param><key>gain</key><value>60</value></param>
<param><key>sources</key><value>4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0_0_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>equalize_chains_0</source_block_id><sink_block_id>ofdm_ofdm_mrx_frame_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>equalize_chains_0</source_block_id><sink_block_id>ofdm_ofdm_mrx_frame_sink_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>equalize_chains_0</source_block_id><sink_block_id>ofdm_ofdm_mrx_frame_sink_0</sink_block_id><source_key>2</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>equalize_chains_0</source_block_id><sink_block_id>ofdm_ofdm_mrx_frame_sink_0</sink_block_id><source_key>3</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>ofdm_packet_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>ofdm_m_channel_sync_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0</source_block_id><sink_block_id>ofdm_m_channel_sync_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0</source_block_id><sink_block_id>ofdm_m_channel_sync_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>ofdm_eadf_doa_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_m_channel_sync_0</source_block_id><sink_block_id>equalize_chains_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>ofdm_m_channel_sync_0</source_block_id><sink_block_id>equalize_chains_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_m_channel_sync_0</source_block_id><sink_block_id>ofdm_ofdm_mrx_frame_sink_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_m_channel_sync_0</source_block_id><sink_block_id>equalize_chains_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_m_channel_sync_0</source_block_id><sink_block_id>equalize_chains_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_m_channel_sync_0</source_block_id><sink_block_id>equalize_chains_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>ofdm_m_channel_sync_0</source_block_id><sink_block_id>equalize_chains_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>ofdm_ofdm_mrx_frame_sink_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>header_dfe</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>ofdm_ofdm_mrx_frame_sink_0</source_block_id><sink_block_id>ofdm_eadf_doa_0</sink_block_id><source_key>header_dfe</source_key><sink_key>Chan_Est</sink_key></connection>
<connection><source_block_id>ofdm_ofdm_mrx_frame_sink_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_ofdm_mrx_frame_sink_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_ofdm_mrx_frame_sink_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_ofdm_mrx_frame_sink_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_ofdm_mrx_frame_sink_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>packet</source_key><sink_key>store</sink_key></connection>
<connection><source_block_id>ofdm_packet_sync_0</source_block_id><sink_block_id>ofdm_m_channel_sync_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_packet_sync_0</source_block_id><sink_block_id>ofdm_m_channel_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_packet_sync_0</source_block_id><sink_block_id>ofdm_m_channel_sync_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>fft_filter_xxx_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>fft_filter_xxx_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>twinrx_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>twinrx_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>twinrx_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>twinrx_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
</flow_graph>
