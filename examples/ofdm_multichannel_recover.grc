<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ofdm_mc_recover</value></param>
<param><key>author</key><value>Travis Collins</value></param>
<param><key>category</key><value>ofdm</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>OFDM Mutichannel Recover</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>mods[modulation]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>(float(occupied_carriers) / float(fft_len)) / 2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ks0</value></param>
<param><key>value</key><value>gp.gen_preamble_data(fft_len, occupied_carriers)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mods</value></param>
<param><key>value</key><value>{"bpsk": 2, "qpsk": 4, "8psk": 8, "qam8": 8, "qam16": 16, "qam64": 64, "qam256": 256}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulation</value></param>
<param><key>value</key><value>'bpsk'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phgain</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rcvd_pktq</value></param>
<param><key>value</key><value>gr.msg_queue()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rotated_const</value></param>
<param><key>value</key><value>gp.gen_framer_info(modulation)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tb</value></param>
<param><key>value</key><value>bw*0.08</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>watcher</value></param>
<param><key>value</key><value>pp._queue_watcher_thread(rcvd_pktq)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>win</value></param>
<param><key>value</key><value>[1 for i in range(fft_len)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zeros_on_left</value></param>
<param><key>value</key><value>int(math.ceil((fft_len - occupied_carriers)/2.0))</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>label</key><value>CP Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>filter.firdes.low_pass (1.0, 1.0, bw+tb, tb, filter.firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>filter.firdes.low_pass (1.0, 1.0, bw+tb, tb, filter.firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>label</key><value>FFT Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import ofdm.gen_preamble as gp</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>from gnuradio import gr</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_1</value></param>
<param><key>import</key><value>import ofdm.packet_process as pp</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_2</value></param>
<param><key>import</key><value>import ofdm.gen_preamble as gp</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_fft_shift</value></param>
<param><key>label</key><value>Max FFT Shift</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>label</key><value>Occupied Carriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>ofdm_no_acq</key>
<param><key>id</key><value>ofdm_no_acq_0</value></param>
<param><key>cp_len</key><value>32</value></param>
<param><key>fftlen</key><value>64</value></param>
<param><key>max_fft_shift</key><value>4</value></param>
<param><key>occupied_carriers</key><value>48</value></param>
</block>
<block>
<key>ofdm_ofdm_mrx_frame_sink</key>
<param><key>id</key><value>ofdm_ofdm_mrx_frame_sink_0</value></param>
<param><key>frq_gain</key><value>phgain*phgain /4.0</value></param>
<param><key>queue</key><value>rcvd_pktq</value></param>
<param><key>occ_tones</key><value>occupied_carriers</value></param>
<param><key>ph_gain</key><value>phgain</value></param>
<param><key>inputs</key><value>ports</value></param>
<param><key>syms</key><value>rotated_const</value></param>
<param><key>vals</key><value>range(arity)</value></param>
</block>
<block>
<key>ofdm_packet_sync</key>
<param><key>id</key><value>ofdm_packet_sync_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
</block>
<block>
<key>ofdm_preamble_equalize</key>
<param><key>id</key><value>ofdm_preamble_equalize_0</value></param>
<param><key>cplen</key><value>cp_len</value></param>
<param><key>fft_length</key><value>fft_len</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
</block>
<block>
<key>ofdm_preamble_equalize</key>
<param><key>id</key><value>ofdm_preamble_equalize_0_0</value></param>
<param><key>cplen</key><value>cp_len</value></param>
<param><key>fft_length</key><value>fft_len</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
</block>
<block>
<key>ofdm_sync_channel</key>
<param><key>id</key><value>ofdm_sync_channel_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>fftlen</key><value>fft_len</value></param>
<param><key>max_fft_shift</key><value>max_fft_shift</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>const</value></param>
<param><key>num_streams</key><value>ports</value></param>
<param><key>vlen</key><value>occupied_carriers</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>packet</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>header_dfe</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>num_streams</key><value>ports</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ports</value></param>
<param><key>label</key><value>RX Chains</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>ofdm_packet_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>ofdm_no_acq_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_no_acq_0</source_block_id><sink_block_id>ofdm_preamble_equalize_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_ofdm_mrx_frame_sink_0</source_block_id><sink_block_id>pad_sink_1_0</sink_block_id><source_key>header_dfe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ofdm_ofdm_mrx_frame_sink_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_ofdm_mrx_frame_sink_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_ofdm_mrx_frame_sink_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>packet</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ofdm_packet_sync_0</source_block_id><sink_block_id>ofdm_no_acq_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_packet_sync_0</source_block_id><sink_block_id>ofdm_sync_channel_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_packet_sync_0</source_block_id><sink_block_id>ofdm_no_acq_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_packet_sync_0</source_block_id><sink_block_id>ofdm_sync_channel_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_packet_sync_0</source_block_id><sink_block_id>ofdm_sync_channel_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_preamble_equalize_0</source_block_id><sink_block_id>ofdm_ofdm_mrx_frame_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_preamble_equalize_0_0</source_block_id><sink_block_id>ofdm_ofdm_mrx_frame_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_sync_channel_0</source_block_id><sink_block_id>ofdm_preamble_equalize_0</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_sync_channel_0</source_block_id><sink_block_id>ofdm_preamble_equalize_0_0</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_sync_channel_0</source_block_id><sink_block_id>ofdm_preamble_equalize_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_sync_channel_0</source_block_id><sink_block_id>ofdm_ofdm_mrx_frame_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_sync_channel_0</source_block_id><sink_block_id>ofdm_preamble_equalize_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_sync_channel_0</source_block_id><sink_block_id>ofdm_preamble_equalize_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
