<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>equalize_chains</value></param>
<param><key>category</key><value>ofdm</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Equalize Chains</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>label</key><value>CP Len</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>label</key><value>FFT Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nports</value></param>
<param><key>label</key><value>Ports</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>label</key><value>Occupied Carriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>ofdm_preamble_equalize</key>
<param><key>id</key><value>ofdm_preamble_equalize_0</value></param>
<param><key>cplen</key><value>cp_len</value></param>
<param><key>fft_length</key><value>fft_len</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
</block>
<block>
<key>ofdm_preamble_equalize</key>
<param><key>id</key><value>ofdm_preamble_equalize_0_0</value></param>
<param><key>cplen</key><value>cp_len</value></param>
<param><key>fft_length</key><value>fft_len</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
</block>
<block>
<key>ofdm_preamble_equalize</key>
<param><key>id</key><value>ofdm_preamble_equalize_0_1</value></param>
<param><key>cplen</key><value>cp_len</value></param>
<param><key>fft_length</key><value>fft_len</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
</block>
<block>
<key>ofdm_preamble_equalize</key>
<param><key>id</key><value>ofdm_preamble_equalize_0_1_0</value></param>
<param><key>cplen</key><value>cp_len</value></param>
<param><key>fft_length</key><value>fft_len</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
<param><key>num_streams</key><value>nports</value></param>
<param><key>vlen</key><value>occupied_carriers</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_a</value></param>
<param><key>label</key><value>est</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>occupied_carriers</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_g</value></param>
<param><key>label</key><value>sig</value></param>
<param><key>num_streams</key><value>nports</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_z</value></param>
<param><key>label</key><value>carr_est</value></param>
<param><key>type</key><value>int</value></param>
</block>
<connection><source_block_id>ofdm_preamble_equalize_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_preamble_equalize_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_preamble_equalize_0_1</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_preamble_equalize_0_1_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pad_source_a</source_block_id><sink_block_id>ofdm_preamble_equalize_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_a</source_block_id><sink_block_id>ofdm_preamble_equalize_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_a</source_block_id><sink_block_id>ofdm_preamble_equalize_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_a</source_block_id><sink_block_id>ofdm_preamble_equalize_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_g</source_block_id><sink_block_id>ofdm_preamble_equalize_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_g</source_block_id><sink_block_id>ofdm_preamble_equalize_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_g</source_block_id><sink_block_id>ofdm_preamble_equalize_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_g</source_block_id><sink_block_id>ofdm_preamble_equalize_0_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_z</source_block_id><sink_block_id>ofdm_preamble_equalize_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_z</source_block_id><sink_block_id>ofdm_preamble_equalize_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_z</source_block_id><sink_block_id>ofdm_preamble_equalize_0_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_z</source_block_id><sink_block_id>ofdm_preamble_equalize_0_1_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
