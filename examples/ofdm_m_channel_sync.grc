<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ofdm_m_channel_sync</value></param>
<param><key>category</key><value>ofdm</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>OFDM Multi-Channel Sync</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nports</value></param>
<param><key>value</key><value>sync.ports</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>sync</value></param>
<param><key>field0</key><value>ports</value></param>
<param><key>value0</key><value>4</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>a</value></param>
<param><key>import</key><value>import ofdm</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>label</key><value>CP Len</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>label</key><value>FFT Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_fft_shift</value></param>
<param><key>label</key><value>max_fft_shift</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nports</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Ports</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>label</key><value>Occupied Carriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>ofdm_no_acq</key>
<param><key>id</key><value>ofdm_no_acq_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>fftlen</key><value>fft_len</value></param>
<param><key>max_fft_shift</key><value>max_fft_shift</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
</block>
<block>
<key>ofdm_no_acq</key>
<param><key>id</key><value>ofdm_no_acq_0_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>fftlen</key><value>fft_len</value></param>
<param><key>max_fft_shift</key><value>max_fft_shift</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
</block>
<block>
<key>ofdm_no_acq</key>
<param><key>id</key><value>ofdm_no_acq_0_0_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>fftlen</key><value>fft_len</value></param>
<param><key>max_fft_shift</key><value>max_fft_shift</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
</block>
<block>
<key>ofdm_sync_channel</key>
<param><key>id</key><value>ofdm_sync_channel_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>fftlen</key><value>fft_len</value></param>
<param><key>max_fft_shift</key><value>max_fft_shift</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>est</value></param>
<param><key>vlen</key><value>occupied_carriers</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
<param><key>num_streams</key><value>nports</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_a</value></param>
<param><key>type</key><value>int</value></param>
<param><key>label</key><value>coarse_freq</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_z</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>flag</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>flag</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>freq</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>sig</value></param>
<param><key>num_streams</key><value>nports</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>ofdm_no_acq_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_no_acq_0_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_no_acq_0_0_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>ofdm_sync_channel_0</source_block_id><sink_block_id>pad_sink_a</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_sync_channel_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_sync_channel_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_sync_channel_0</source_block_id><sink_block_id>pad_sink_z</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ofdm_no_acq_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ofdm_no_acq_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ofdm_no_acq_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ofdm_sync_channel_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>ofdm_no_acq_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>ofdm_no_acq_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>ofdm_no_acq_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>ofdm_sync_channel_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>ofdm_sync_channel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>ofdm_no_acq_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>ofdm_no_acq_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>ofdm_no_acq_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
</flow_graph>
