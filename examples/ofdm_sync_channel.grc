<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ofdm_sync_channel</value></param>
<param><key>category</key><value>ofdm</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>OFDM Sync Channel</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ks0</value></param>
<param><key>value</key><value>gp.gen_preamble_data(fftlen, occupied_carriers)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>win</value></param>
<param><key>value</key><value>[1 for i in range(fftlen)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zeros_on_left</value></param>
<param><key>value</key><value>int(math.ceil((fftlen - occupied_carriers)/2.0))</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>label</key><value>CP Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>digital_ofdm_sampler</key>
<param><key>id</key><value>digital_ofdm_sampler_0</value></param>
<param><key>fft_length</key><value>fftlen</value></param>
<param><key>symbol_length</key><value>cp_len+fftlen</value></param>
<param><key>timeout</key><value>1000000</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fftlen</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>win</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>label</key><value>FFT Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import ofdm.gen_preamble as gp</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_fft_shift</value></param>
<param><key>label</key><value>Max FFT Shift</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>label</key><value>Occupied Carriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>ofdm_frame_acquisition</key>
<param><key>id</key><value>ofdm_frame_acquisition_0_0</value></param>
<param><key>cplen</key><value>cp_len</value></param>
<param><key>fft_length</key><value>fftlen</value></param>
<param><key>max_fft_shift_len</key><value>max_fft_shift</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>known_symbol</key><value>ks0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>flag</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>est</value></param>
<param><key>vlen</key><value>occupied_carriers</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>fftout</value></param>
<param><key>vlen</key><value>fftlen</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>label</key><value>coarse_freq</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>Signal</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>Freq</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0</value></param>
<param><key>label</key><value>flag</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>digital_ofdm_sampler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_sampler_0</source_block_id><sink_block_id>ofdm_frame_acquisition_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_ofdm_sampler_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>ofdm_frame_acquisition_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_frame_acquisition_0_0</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_frame_acquisition_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_frame_acquisition_0_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0</source_block_id><sink_block_id>digital_ofdm_sampler_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
