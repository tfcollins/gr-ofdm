<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_speed</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>overlap</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>snapshot</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>4*4</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>16</value></param>
</block>
<block>
<key>doa_autocorrelate</key>
<param><key>id</key><value>doa_autocorrelate_0</value></param>
<param><key>avg_method</key><value>0</value></param>
<param><key>inputs</key><value>4</value></param>
<param><key>overlap_size</key><value>overlap</value></param>
<param><key>snapshot_size</key><value>snapshot</value></param>
</block>
<block>
<key>ofdm_stop_on_overflow</key>
<param><key>id</key><value>ofdm_stop_on_overflow_0</value></param>
</block>
<block>
<key>uhd_amsg_source</key>
<param><key>id</key><value>uhd_amsg_source_0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.40.2"</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>uhd_async_msg_printer</key>
<param><key>id</key><value>uhd_async_msg_printer_0</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>src</key><value>"addr='192.168.40.2'"</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>2.45e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>ant1</key><value></value></param>
<param><key>center_freq1</key><value>2.45e9</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>10</value></param>
<param><key>ant2</key><value></value></param>
<param><key>center_freq2</key><value>2.45e9</value></param>
<param><key>dc_offs_enb2</key><value>""</value></param>
<param><key>iq_imbal_enb2</key><value>""</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>10</value></param>
<param><key>ant3</key><value></value></param>
<param><key>center_freq3</key><value>2.45e9</value></param>
<param><key>dc_offs_enb3</key><value>""</value></param>
<param><key>iq_imbal_enb3</key><value>""</value></param>
<param><key>norm_gain3</key><value>False</value></param>
<param><key>gain3</key><value>10</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.40.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>"A:0 A:1 B:0 B:1"</value></param>
<param><key>nchan</key><value>4</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>doa_autocorrelate_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_autocorrelate_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_amsg_source_0</source_block_id><sink_block_id>uhd_async_msg_printer_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>ofdm_stop_on_overflow_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
</flow_graph>
